FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://0001-Y2038-zlib-Do-not-undef-_FILE_OFFSET_BITS-for-Y2038-.patch"
