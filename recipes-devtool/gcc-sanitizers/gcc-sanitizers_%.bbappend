CFLAGS:remove = "-D_TIME_BITS=64 -D_FILE_OFFSET_BITS=64"
CPPFLAGS:remove = "-D_TIME_BITS=64 -D_FILE_OFFSET_BITS=64"
CXXFLAGS:remove = "-D_TIME_BITS=64 -D_FILE_OFFSET_BITS=64"
